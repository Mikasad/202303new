# Keil uVision project pro800.uvprojx, settings and files
target pro800 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.6
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 40_pro800V3 +hex
  AfterMake: fromelf.exe --bin -o ./pro800/@L.bin ./Objects/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER, __FPU_PRESENT
  c include: ../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;..\App;..\App\buf;..\App\can_task;..\App\cmdLine;..\App\debug;..\App\iwdg;..\App\motor;..\App\motor\bldc_driver;..\App\motor\daneng_driver;..\App\nanopb;..\App\normal_io;..\App\pc_correspond;..\App\security_module;..\App\sensor;..\App\sensor\gyro_task\hi216;..\App\sensor\rfid;..\App\sensor\rfid\m6e;..\App\sensor\sensor_hub;..\App\sensor\ultrasonic;..\App\sensor\ultrasonic\ks136;..\App\system_error_code;..\App\scada;..\App\flash;..\App\rtc;..\App\bms;..\App\sensor\anti_drop&collision;..\App\sensor\gyro_task;..\App\h25a15;..\HC32_Drivers\cmsis\Include;..\HC32_Drivers\hc32_ll_driver\inc;..\HC32_Source;..\HC32_Drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\App\sensor\gyro_task\jc310;..\App\hub_motor;..\HC32_Drivers\hc32_usb_driver;..\HC32_Drivers\hc32_usb_driver\usb_host_lib\host_class\msc;..\HC32_Drivers\hc32_usb_driver\usb_host_lib\host_core;..\HC32_Source\usb;..\Middlewares\Third_Party\FatFs\src;..\App\ota;..\misc_device\Inc;..\package\flash;..\package\bms;..\Middlewares\ringbuf;..\App\sensor\gyro_task\zyf143;..\package\power_ctr;..\package\disinfect_bag;..\package\backpack
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x40000 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  group MDK-ARM
    ../HC32_Drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
    ../HC32_Drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
  group app
    ../App/security_module/: security_state.c
    ../App/: version.h main.c
    ../misc_device/Src/: ethernetif.c freertos.c tcp_server.c app_ethernet.c
  group Application/HC32_Source
    ../HC32_Source/: hc_adc.c hc_crc.c hc_extint.c hc_gpio.c hc_spi.c hc_usart.c ring_buf.c sysclock.c hc32f4xx_conf.h hc_can.c hc_uart1.c hc_uart2.c
  group module
    ../App/pc_correspond/: pc_correspond.c
    ../App/motor/: ctr_move_task.c HollySys.c zd_driver.c
    ../App/can_task/: can_task.c
    ../App/normal_io/: normal_io.c
    ../App/sensor/ultrasonic/ks136/: ks136.c
    ../App/scada/: scada.c
    ../App/motor/daneng_driver/: XD510.c
    ../App/sensor/anti_drop&collision/: anti_drop_collision.c
    ../App/sensor/rfid/: rfid_etag.c
    ../App/sensor/gyro_task/hi216/: gyro_hi216.c
    ../package/power_ctr/: power_ctr.c
    ../package/disinfect_bag/: disinfect_bag.c
    ../package/backpack/: drv_backpack.c
  group mydriver
    ../App/pc_correspond/: nanopb_tcpip.c
    ../App/buf/: mutex_can_buf.c
    ../App/flash/: flash_op.c
    ../App/can_task/: objdict.c
    ../App/sensor/anti_drop&collision/: anti_collision.c
    ../App/sensor/gyro_task/: imu_task.c
    ../App/motor/: xds_blvacuum.c
    ../App/hub_motor/: app_hub_motor.c drv_zlac8015.c
    ../App/bms/: app_bms.c
    ../App/h25a15/: drv_h4aa30_usb_iap.c app_h25a15.c drv_h25a15.c app_h25a15_ota.c
    ../App/ota/: app_ota.c drv_ota.c
    ../App/sensor/gyro_task/zyf143/: gyro_zyf143.c
  group nanopb
    ../App/nanopb/: pb_common.c pb_decode.c pb_encode.c service.pb.c
  group Driver/HC32_LL_Driver
    ../HC32_Drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_crc.c hc32_ll_dma.c hc32_ll_eth.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_efm.c hc32_ll_interrupts.c hc32_ll_rtc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_tmr0.c hc32_ll_tmr2.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_aos.c hc32_ll_usb.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/HC32_USB_Driver
    ../HC32_Drivers/hc32_usb_driver/usb_host_lib/host_class/msc/: usb_host_msc_bot.c usb_host_msc_class.c usb_host_msc_fatfs.c usb_host_msc_scsi.c
    ../HC32_Drivers/hc32_usb_driver/usb_host_lib/host_core/: usb_host_cfgch.c usb_host_core.c usb_host_ctrltrans.c usb_host_driver.c usb_host_int.c usb_host_stdreq.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/: fatfs.c
  group Middlewares/ringbuff
    ../Middlewares/ringbuf/: ringbuffer.c
  group Driver/user_usb_driver
    ../HC32_Source/usb/: usb_bsp.c usb_host_user.c
  group package
    ../package/flash/: GD25Q32C.c
    ../package/bms/: bms.c drv_gs_can_bms.c
software components: CMSIS:CORE 5.5.0
